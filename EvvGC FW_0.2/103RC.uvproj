# Keil uVision project 103RC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 103RC +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s main.c system_stm32f10x.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c misc.c
